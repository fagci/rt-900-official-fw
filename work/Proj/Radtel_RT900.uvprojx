# Keil uVision project Radtel_RT900.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Radtel_RT900 +hex
  AfterMake: C:\Keil_v5\C51\BIN\ARCEncryptTools.exe ./Output/Radtel_RT900.hex QzBtDzKjYxGsWalkieTalkieBt8000OpenDate20241202
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\source\App;..\source\BSP;..\source\Common;..\source\Core;..\source\CPS;..\source\Driver;..\source\Gui;..\source\Interface;..\source\Libraries;..\source\Libraries\CMSIS;..\source\Libraries\CMSIS\Device;..\source\Libraries\CMSIS\Include;..\source\Libraries\StdPeriph_Driver;..\source\Libraries\StdPeriph_Driver\inc;..\source\Libraries\StdPeriph_Driver\src;..\source\Voice
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x40000
  memory RVCT9: RAM 0x200000c0 size 0x8000
  group CMSIS
    ../source/Libraries/CMSIS/Device/: startup_bt32f0x.s
    ../source/Libraries/StdPeriph_Driver/src/: system_bt32f0x.c
    ../source/BSP/: bt32f0x_it.c
  group StdPeriph_Driver
    ../source/Libraries/StdPeriph_Driver/src/: bt32f0x_adc.c bt32f0x_crc.c bt32f0x_dma.c bt32f0x_flash.c bt32f0x_gpio.c bt32f0x_iwdg.c bt32f0x_misc.c bt32f0x_pwr.c bt32f0x_rcc.c bt32f0x_spi.c bt32f0x_tim.c bt32f0x_usart.c bt32f0x_wwdg.c bt32f0x_syscfg.c
  group BSP
    ../source/BSP/: Board.c BoardFun.c
  group APP
    ../source/App/: AppAlarm.c AppFm.c AppMain.c AppMenu.c AppMoni.c AppScan.c AppScanQT.c AppSearch.c AppTask.c AppWeather.c Battery.c DualStandby.c main.c AppDtmf.c
  group CPS
    ../source/CPS/: ProgromFlash.c
  group Core
    ../source/Core/: Radio.c RadioTask.c
  group Driver
    ../source/Driver/: crc.c DevBK4819.c DevBK4819Data.c FlashFont.c key_ptt.c keyboard.c NorFlash.c RadioDataReset.c RadioDataStorage.c Rda5807.c st7735s.c Systick.c
    ../source/Core/: Functions.c
  group Interface
    ../source/Interface/: i2c.c
  group GUI
    ../source/Gui/: DisplayBattery.c DisplayDtmf.c DisplayFm.c DisplayInputbox.c DisplayMain.c DisplayMenu.c DisplayPowerOn.c DisplayScanQT.c DisplaySearch.c DisplayWeather.c LcdFillDot.c
  group Voice
    ../source/Voice/: Beep.c VoiceBroadcast.c
  group Common
    ../source/Common/: BitMap.c Delay.c Globe.c
